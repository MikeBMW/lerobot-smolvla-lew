VERSION "1.0"
// ═══════════════════════════════════════════════════
// feature.dbc — 能力数据库 (参考 Vector CANoe DBC)
// 同一平台/容器内配置不同模型的能力接入, 第三方模型按文件接入
// ═══════════════════════════════════════════════════

// 模型节点 (平台内可配置的模型/第三方接入点)
BU_: JOB_MODEL GUIDE_MODEL SCHED_MODEL PERCEPT_MODEL THIRD_PARTY

// 数据流形态 (状态空间=形态之一)
FLOW_: L0 "L0" "多机台·多车协同调度 · 场景编排"
FLOW_: L1 "L1" "作业阶段编排 · 原子技能库 (200项)"
FLOW_: L2 "L2" "作业执行 + 预判引导 (模型可替换)"
FLOW_: L3 "L3" "感知认知 · 作业执行 · 移动流转"
FLOW_: JOB_MODEL "L2 模型决策 · 从看到做 (70ms 级)" "作业执行模型" JOB_MODEL
FLOW_: GUIDE_MODEL "L2 模型决策 · 预判过程走向" "预判引导模型" GUIDE_MODEL
FLOW_: SCHED_MODEL "L1 技能编排 · 阶段调度与说明" "作业编排模型" SCHED_MODEL
FLOW_: PERCEPT_MODEL "L3 感知执行 · 识别定位检测" "感知模型" PERCEPT_MODEL
FLOW_: THIRD_PARTY "按需注册 Manifest + 适配器" "第三方模型" THIRD_PARTY

// 能力 (BO_) 与 输入输出信号 (SG_), 接口取值: IN/OUT/CFG/TRAIN/DEPLOY/EVAL/MON/SCHED
// ── A 移动流转能力 ──
BO_ A1 自主导航流转: IN/OUT A
 SG_ 简述 : 64 "跨工位自主移动, 移动即工位"
 SG_ 解释 : 512 "能自主规划路径在工位之间流转, 一台车串联整条产线工序。这是 R MPV「移动即工位」的核心能力: 不再被动等待物料, 而是主动导航至物料、自主流转至下一工位, 替代固定设备的跨工位人力搬运。"
 SG_ 接口定义 : 512 "移动指令接口：输入目标工位与环境信息, 输出移动指令与到位状态。第三方导航方案按接口输出移动能力即可接入。"
 SG_ 输入 : 24 "目标工位 (任务分配)；环境感知信息 (导航)"
 SG_ 输出 : 64 "移动指令 (速度/方向)；到位状态 (到达/偏差)"
 SG_ 场景 : 128 "上下料搬运 · 老化箱 · 热海柜体 · ATS 跨工位流转"
 SG_ 工程 : 128 "移动导航模块"
 SG_ 归属 : 64 "全模型通用"
BO_ A2 工位精准对接: OUT A
 SG_ 简述 : 64 "到位定位, 对接精度 ±10mm 级"
 SG_ 解释 : 512 "能在工位前精准停靠对接, 视觉定位定位销/对接标记, 保证后续作业的坐标系基准正确。对接精度不足会放大到末端, 是跨工位作业链的精度起点。"
 SG_ 接口定义 : 512 "对接指令接口：输入对接目标, 输出对接位姿与完成确认。"
 SG_ 输入 : 24 "工位对接标记/定位销 (视觉定位)；工位坐标系信息"
 SG_ 输出 : 64 "对接位姿 (相对工位)；对接完成确认"
 SG_ 场景 : 128 "上下料对接 · 老化箱对接 · 测试台对接"
 SG_ 工程 : 128 "工位对接模块"
 SG_ 归属 : 64 "全模型通用"
BO_ A3 举升高度调节: OUT/CFG A
 SG_ 简述 : 64 "垂直举升 0~800mm, 覆盖多层工位"
 SG_ 解释 : 512 "能通过举升机构把作业上装调节到目标高度, 覆盖从料架底部到老化箱高层的全高度作业, 替代人工弯腰/踮脚取放。"
 SG_ 接口定义 : 512 "举升指令接口：输入目标高度, 输出举升指令与到位确认；高度参数可现场配置。"
 SG_ 输入 : 24 "目标高度 (作业层高)；举升限位 (CFG)"
 SG_ 输出 : 64 "举升指令 (速度/目标)；到位确认"
 SG_ 场景 : 128 "老化箱多层插拔 · 料架高层取放"
 SG_ 工程 : 128 "举升立柱模块"
 SG_ 归属 : 64 "全模型通用"
BO_ A4 双形态作业: CFG A
 SG_ 简述 : 64 "固定式/移动式按需切换"
 SG_ 解释 : 512 "能在固定式（支脚落地锁死, 精度最优）与移动式（自主流转, 柔性最优）之间切换, 兼顾精度与柔性, 同一台车适配不同产线布局。"
 SG_ 接口定义 : 512 "形态配置接口：输入形态指令, 输出切换完成状态。"
 SG_ 输入 : 24 "形态指令 (固定/移动) + 当前形态状态"
 SG_ 输出 : 64 "切换完成状态 (支脚/驱动状态)"
 SG_ 场景 : 128 "精度优先工位 (固定) · 柔性流转工位 (移动)"
 SG_ 工程 : 128 "双形态切换模块"
 SG_ 归属 : 64 "全模型通用"
// ── B 感知认知能力 ──
BO_ B1 目标识别定位: IN B
 SG_ 简述 : 64 "识别工件/孔位/托盘/料盒并给出位置"
 SG_ 解释 : 512 "能自动识别作业环境中的光模块、插槽、料盘、料盒等目标并给出位置, 是「看得见」的基础能力, 一切抓取与插拔的前提。"
 SG_ 接口定义 : 512 "输入观测接口 (IN)：输入现场图像, 输出目标类别与位置清单。感知类模型按接口提供识别结果即可复用下游流程。"
 SG_ 输入 : 24 "现场图像 (头部相机, 800万像素级)"
 SG_ 输出 : 64 "目标清单 (类别/置信度/位置框)"
 SG_ 场景 : 128 "抓取前找模块 · 插拔前找插槽 · 上下料认料盘"
 SG_ 工程 : 128 "感知识别模块"
 SG_ 归属 : 64 "感知模型（例）· 作业执行模型（例）"
BO_ B2 空间位姿感知: IN B
 SG_ 简述 : 64 "感知目标三维位置与朝向"
 SG_ 解释 : 512 "能把识别到的目标放到三维空间中理解, 知道它在哪、朝向哪, 支撑抓取点计算、插拔对准与放置规划。"
 SG_ 接口定义 : 512 "输入观测接口 (IN)：在识别结果上扩展空间信息, 输出目标三维位姿。"
 SG_ 输入 : 24 "目标识别结果 + 现场深度/标定信息"
 SG_ 输出 : 64 "目标三维位姿 (位置/朝向/置信度)"
 SG_ 场景 : 128 "插拔对准 · 抓取点计算 · 放置规划"
 SG_ 工程 : 128 "空间换算模块"
 SG_ 归属 : 64 "全模型通用"
BO_ B3 触感感知: IN B
 SG_ 简述 : 64 "感知接触状态与力度大小"
 SG_ 解释 : 512 "能感知末端与物体的接触及力度, 知道「碰到了」「用多大力」, 是力控保护、抓取力度控制、插拔到位判断的基础。"
 SG_ 接口定义 : 512 "输入观测接口 (IN)：输入触觉信号, 输出接触状态与力度。"
 SG_ 输入 : 24 "触觉原始信号 (力/力矩分量, 多通道)；采样时间戳"
 SG_ 输出 : 64 "接触状态 · 力度 (大小/方向) · 力度变化率"
 SG_ 场景 : 128 "插拔接触判断 · 抓取力度控制 · 防损伤"
 SG_ 工程 : 128 "触感感知通道"
 SG_ 归属 : 64 "全模型通用"
BO_ B4 自身状态感知: IN/CFG B
 SG_ 简述 : 64 "感知关节/末端/基座状态"
 SG_ 解释 : 512 "能持续感知自身关节、末端、基座的状态, 知道自己「手在哪儿、车在哪儿」, 是所有位置闭环与状态上报的公共前提。"
 SG_ 接口定义 : 512 "输入观测接口 (IN) + 参数配置接口 (CFG)：状态维度可配置, 适配不同模型。"
 SG_ 输入 : 24 "关节编码 · 运动学参数 · 基座定位信息"
 SG_ 输出 : 64 "关节状态 · 末端状态 · 基座状态 (按配置组装)"
 SG_ 场景 : 128 "全模型共用 · 位置闭环 · 状态上报"
 SG_ 工程 : 128 "状态组装模块"
 SG_ 归属 : 64 "全模型通用"
BO_ B5 外观质量检测: IN/MON B
 SG_ 简述 : 64 "检测金手指划痕/端面脏污/外观缺陷"
 SG_ 解释 : 512 "能在作业过程中对模块金手指、端面、外观做质量检测, 判定划痕/脏污/缺陷, 把检测从人工目检升级为自动化, 直接支撑良率目标。"
 SG_ 接口定义 : 512 "输入观测接口 (IN) + 监控上报接口 (MON)：输入检测图像, 输出缺陷判定并上报。"
 SG_ 输入 : 24 "检测图像 (金手指/端面/外观, 多面拍摄)"
 SG_ 输出 : 64 "缺陷判定 (类别/位置/等级)；检测记录"
 SG_ 场景 : 128 "FW Loading 金手指检测 · ATS 端面检测 · 分拣判级"
 SG_ 工程 : 128 "质量检测模块"
 SG_ 归属 : 64 "感知模型（例）"
// ── C 作业执行能力 ──
BO_ C1 完整作业执行: OUT C
 SG_ 简述 : 64 "从看到做, 独立完成连贯作业"
 SG_ 解释 : 512 "能通过学习掌握一套完整作业动作, 从看到工件开始自主完成抓取、翻转、插拔、分拣等连贯动作, 中途无需人工干预每一步。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：输入现场观测, 输出完整动作序列。"
 SG_ 输入 : 24 "现场观测 (图像/状态/触感, 按模型组合)"
 SG_ 输出 : 64 "动作序列 (关节目标/夹爪/节奏)"
 SG_ 场景 : 128 "5 大场景完整作业 · 数据充分的任务"
 SG_ 工程 : 128 "作业执行策略"
 SG_ 归属 : 64 "作业执行模型（例）"
BO_ C2 精细对位: CFG/OUT C
 SG_ 简述 : 64 "亚毫米级对准, 末端 ±0.02mm 级"
 SG_ 解释 : 512 "能把末端精确对准目标位置, 三级精度逐级收敛 (工位±2mm → 视觉引导±0.1mm → 力控微调±0.02mm), 支撑金手指零划痕插拔。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT) + 参数配置接口 (CFG)：对位目标与允许偏差可配置。"
 SG_ 输入 : 24 "目标位姿 + 当前状态 + 允许偏差 (CFG)"
 SG_ 输出 : 64 "对位指令 · 对位状态 (到位/偏差)"
 SG_ 场景 : 128 "插拔对准 · 治具对接 · 精密取放"
 SG_ 工程 : 128 "对位模块"
 SG_ 归属 : 64 "作业执行模型（例）"
BO_ C3 力控插拔保护: OUT/MON C
 SG_ 简述 : 64 "插拔过程防损伤, 力控 ≤2N 级"
 SG_ 解释 : 512 "能在插拔过程中感知力度并自动保护, 插入力控制在极小范围, 超限即调整或停止, 保护模块金手指与壳体, 是良率与安全的底线能力。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT) + 监控上报接口 (MON)：输入力度反馈, 输出保护调整/停止, 上报保护事件。"
 SG_ 输入 : 24 "力度反馈 + 安全阈值 (CFG)"
 SG_ 输出 : 64 "保护指令 (调整/停止) + 保护事件记录"
 SG_ 场景 : 128 "模块插拔 · 金手指保护 · 压合保护"
 SG_ 工程 : 128 "力控保护模块"
 SG_ 归属 : 64 "全模型通用"
BO_ C4 灵活翻转取放: OUT C
 SG_ 简述 : 64 "翻转 180° 级姿态调整与取放"
 SG_ 解释 : 512 "能对工件做翻转等姿态调整 (如标签面朝下、金手指面朝上), 支撑扫码、检测、插拔前的姿态准备, 让作业不受工件朝向限制。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：输入目标姿态, 输出翻转/取放动作。"
 SG_ 输入 : 24 "目标姿态 (翻转角度/朝向) + 当前姿态"
 SG_ 输出 : 64 "翻转动作 · 取放动作 · 完成确认"
 SG_ 场景 : 128 "FW Loading 翻转 · ATS 姿态准备"
 SG_ 工程 : 128 "翻转执行模块"
 SG_ 归属 : 64 "作业执行模型（例）"
BO_ C5 双臂协同作业: OUT C
 SG_ 简述 : 64 "同步/协同/接力三种协同模式"
 SG_ 解释 : 512 "双臂可同时作业 (吞吐翻倍)、协同作业 (一臂持料一臂操作)、接力作业 (流水线式交接), 大幅提升作业效率与复杂任务完成能力。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：输入协同任务, 输出双臂协调动作。"
 SG_ 输入 : 24 "协同任务 (同步/协同/接力模式)"
 SG_ 输出 : 64 "双臂动作序列 (双臂协调/左右臂分工)；协同完成回执"
 SG_ 场景 : 128 "上下料批量取放 · 光纤接头插拔 · 扫码→翻转→插拔接力"
 SG_ 工程 : 128 "双臂协同模块"
 SG_ 归属 : 64 "作业执行模型（例）"
BO_ C6 宏微复合作业: OUT C
 SG_ 简述 : 64 "大行程快动 + 微调精细分工"
 SG_ 解释 : 512 "把大行程运动交给快速直线机构、末端专注精细微调, 宏微复合互不干扰, 插拔等动作比纯关节插补更快更稳, 直接支撑 ≤6s 节拍。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：输入作业目标, 输出宏动与微调的分工指令。"
 SG_ 输入 : 24 "作业目标 (插拔/搬运任务, 含目标位姿与约束)"
 SG_ 输出 : 64 "宏动指令 (大行程) + 微调指令 (精细)"
 SG_ 场景 : 128 "FW Loading 快速插拔 · 高速取放"
 SG_ 工程 : 128 "宏微复合模块"
 SG_ 归属 : 64 "作业执行模型（例）"
// ── D 决策引导能力 ──
BO_ D1 过程预判: GUIDE D
 SG_ 简述 : 64 "预判后续过程走向, 提前引导"
 SG_ 解释 : 512 "能根据当前作业过程预判下一步走向, 提前调整动作, 让长时序作业更连贯、少返工, 异常出现前就有准备。"
 SG_ 接口定义 : 512 "引导输出接口 (GUIDE)：输入当前过程观测, 输出预判结果 (下一状态/接触概率)。"
 SG_ 输入 : 24 "当前过程观测 (图像/状态/动作历史)"
 SG_ 输出 : 64 "预判结果 (下一状态/接触概率/偏差提示)"
 SG_ 场景 : 128 "老化箱长时序 · 热海柜体多步插拔 · 异常预警"
 SG_ 工程 : 128 "预判引导模块"
 SG_ 归属 : 64 "预判引导模型（例）"
BO_ D2 运动规律建模: OUT D
 SG_ 简述 : 64 "建立运动规律模型, 支撑分析预测"
 SG_ 解释 : 512 "能基于自身运动数据建立运动规律模型, 用于分析作业表现、预测运动结果、指导参数调整, 是稳定性分析与表现预测的基础。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：输入历史过程数据, 输出运动规律模型 (可查询可预测)。"
 SG_ 输入 : 24 "历史过程数据 (状态/动作/时间)"
 SG_ 输出 : 64 "运动规律模型 (状态-控制-运动关系) + 有效性指标 (拟合误差/适用范围)"
 SG_ 场景 : 128 "节拍验证 · 表现预测 · 参数设计"
 SG_ 工程 : 128 "运动建模模块"
 SG_ 归属 : 64 "预判引导模型（例）"
BO_ D3 决策说明: MON D
 SG_ 简述 : 64 "说明当前决策依据, 过程可查"
 SG_ 解释 : 512 "能说明每一步决策的理由, 作业过程可解释、可回溯, 方便监督与问题归因, 评审时拿得出依据。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：输入当前观测与决策, 输出决策依据说明。"
 SG_ 输入 : 24 "当前观测 (图像/状态/触感) + 当前决策 (动作/阶段指令)"
 SG_ 输出 : 64 "决策依据说明 (要点列表) + 决策置信度 + 关联观测引用"
 SG_ 场景 : 128 "大屏监督 · 异常归因 · 评审验收"
 SG_ 工程 : 128 "决策说明通道"
 SG_ 归属 : 64 "作业编排模型（例）"
// ── E 数据学习能力 ──
BO_ E1 车载数据采集: TRAIN E
 SG_ 简述 : 64 "作业过程自动采集三类数据 (数据飞轮)"
 SG_ 解释 : 512 "在正常作业中持续采集检测图像、操作轨迹、过程数据, 产线作业即产出训练数据, 对接模型训练, 让机器人「干活即产数据」。"
 SG_ 接口定义 : 512 "训练接入接口 (TRAIN)：输入作业过程, 输出结构化采集数据 (图像/轨迹/过程)。"
 SG_ 输入 : 24 "作业过程 (检测图像/操作轨迹/SN工艺数据)"
 SG_ 输出 : 64 "结构化数据 (图像/轨迹/过程记录, 断点续传)"
 SG_ 场景 : 128 "5 大场景作业全程 · 数据飞轮"
 SG_ 工程 : 128 "车载数据采集模块"
 SG_ 归属 : 64 "全模型通用"
BO_ E2 边学边练: TRAIN E
 SG_ 简述 : 64 "现场作业中持续学习提升"
 SG_ 解释 : 512 "现场采集数据持续反哺模型训练, 越用越强, 新工位/新品种上线后模型随数据积累持续变好, 形成数据飞轮正循环。"
 SG_ 接口定义 : 512 "训练接入接口 (TRAIN)：输入采集数据, 输出更新后的能力。"
 SG_ 输入 : 24 "现场采集数据 (检测图像/操作轨迹/过程记录, 持续积累)"
 SG_ 输出 : 64 "更新后的能力 (新模型, 自动部署) + 训练报告 (数据量/指标变化)"
 SG_ 场景 : 128 "产线持续优化 · 新产线快速适配"
 SG_ 工程 : 128 "数据闭环管道"
 SG_ 归属 : 64 "全模型通用"
BO_ E3 上岗考核: EVAL E
 SG_ 简述 : 64 "正式作业前先经仿真考核"
 SG_ 解释 : 512 "新模型正式上岗前先在仿真环境完成能力考核, 考核成功率与作业质量, 达标后才允许真机作业, 现场风险大幅降低。"
 SG_ 接口定义 : 512 "评估接入接口 (EVAL)：输入待考核模型, 输出考核成绩与结论。"
 SG_ 输入 : 24 "待考核模型 (标准格式) + 考核场景配置 (作业任务/难度)"
 SG_ 输出 : 64 "考核成绩 (成功率/质量分) + 结论 + 录像"
 SG_ 场景 : 128 "模型选型 · 训练验收 · 版本对比"
 SG_ 工程 : 128 "仿真考核环境"
 SG_ 归属 : 64 "全模型通用"
// ── F 部署运行能力 ──
BO_ F1 本地实时作业: DEPLOY F
 SG_ 简述 : 64 "机端本地实时完成作业 (70ms 级)"
 SG_ 解释 : 512 "感知、决策、作业全流程在机端本地实时完成, 推理延迟控制在极小范围, 不依赖外部网络, 断网也能持续作业, 满足 24h 连续生产。"
 SG_ 接口定义 : 512 "部署接入接口 (DEPLOY)：输入现场观测, 输出实时作业动作。"
 SG_ 输入 : 24 "现场观测 (实时) + 已部署模型"
 SG_ 输出 : 64 "实时作业动作 (关节/夹爪/移动) + 运行状态 (延迟/占用)"
 SG_ 场景 : 128 "产线实时作业 · 断网可用 · 低延迟"
 SG_ 工程 : 128 "机端运行环境"
 SG_ 归属 : 64 "全模型通用"
BO_ F2 远程升级: DEPLOY F
 SG_ 简述 : 64 "作业中可远程更新模型能力"
 SG_ 解释 : 512 "新模型文件到位后自动加载生效, 作业不停、升级不断, 多台车可批量更新。"
 SG_ 接口定义 : 512 "部署接入接口 (DEPLOY)：输入新模型文件, 输出更新生效状态。"
 SG_ 输入 : 24 "新模型文件 (标准格式) + 版本信息"
 SG_ 输出 : 64 "更新生效状态 (成功/回退) + 当前版本号"
 SG_ 场景 : 128 "远程升级 · 批量部署 · 不停机换模型"
 SG_ 工程 : 128 "模型更新监听"
 SG_ 归属 : 64 "全模型通用"
BO_ F3 多车协同调度: SCHED F
 SG_ 简述 : 64 "多机台多车任务分配与协同"
 SG_ 解释 : 512 "多台 R MPV 统一调度, 任务按工位/节拍智能分配, 车与车、车与设备协同, 支撑整条产线无人化柔性制造。"
 SG_ 接口定义 : 512 "调度接入接口 (SCHED)：输入任务队列与车状态, 输出车-任务分配。"
 SG_ 输入 : 24 "任务队列 + 各车状态 (位置/忙闲)"
 SG_ 输出 : 64 "车-任务分配 (车号/任务/时间) + 路径协调结果"
 SG_ 场景 : 128 "多机台产线 · 老化/测试异步多工位"
 SG_ 工程 : 128 "协同调度模块"
 SG_ 归属 : 64 "全模型通用"
// ── G 对外协作能力 ──
BO_ G1 标准模型接入: IN/OUT G
 SG_ 简述 : 64 "按统一接口接入任意模型"
 SG_ 解释 : 512 "提供统一的模型接入标准, 任何第三方模型按标准接入即可, 接入后共享训练、评估、部署、监控全流程, 模型生态自由扩展。"
 SG_ 接口定义 : 512 "标准接入契约 (IN/OUT 为主, 全接口统一)：输入标准观测, 输出标准动作。"
 SG_ 输入 : 24 "标准观测 (图像/状态/触感, 按契约组装)"
 SG_ 输出 : 64 "标准动作 (关节目标/夹爪/移动指令, 按契约下发)"
 SG_ 场景 : 128 "第三方模型接入 · 模型替换 · 多模型对比"
 SG_ 工程 : 128 "统一接入契约"
 SG_ 归属 : 64 "全模型通用"
BO_ G2 运行状态上报: MON G
 SG_ 简述 : 64 "作业状态与结果实时上报"
 SG_ 解释 : 512 "作业状态、成功率、节拍等运行数据实时上报, 对接大屏与上位系统, 异常即时告警, 指标可统计可验收。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：输入运行数据, 输出上报表/告警。"
 SG_ 输入 : 24 "运行数据 (状态/成功率/节拍/力值)"
 SG_ 输出 : 64 "上报记录 (指标时序) + 告警事件 (超阈值/异常)"
 SG_ 场景 : 128 "大屏监控 · 指标验收 · 异常告警"
 SG_ 工程 : 128 "指标上报通道"
 SG_ 归属 : 64 "全模型通用"
BO_ G3 事件自动通知: MON G
 SG_ 简述 : 64 "关键事件自动通知相关人员"
 SG_ 解释 : 512 "训练完成、作业异常、报告输出等关键事件自动通知相关人员, 无需盯屏, 远程协作不误事。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：输入系统事件, 输出通知消息。"
 SG_ 输入 : 24 "系统事件 (作业完成/异常/报告就绪, 含详情与时间戳)"
 SG_ 输出 : 64 "通知消息 (含附件链接) + 送达回执"
 SG_ 场景 : 128 "远程协作 · 无人盯屏 · 交付同步"
 SG_ 工程 : 128 "消息通知通道"
 SG_ 归属 : 64 "全模型通用"
BO_ G4 产线系统对接: MON/CFG G
 SG_ 简述 : 64 "对接 PLC/MES/联锁信号"
 SG_ 解释 : 512 "能与产线 PLC、MES 系统对接, 交换联锁信号与生产数据, 融入现有产线而不孤立, 满足设备联锁、SN 追溯、生产调度要求。"
 SG_ 接口定义 : 512 "产线对接接口：输入产线信号, 输出联锁状态与生产数据 (Modbus/CAN/网络)。"
 SG_ 输入 : 24 "产线信号 (联锁/指令)；MES 任务"
 SG_ 输出 : 64 "联锁状态 + 生产数据 (SN/结果/节拍)"
 SG_ 场景 : 128 "与键合机联锁 · 与 MES 数据交换 · 产线调度"
 SG_ 工程 : 128 "产线对接模块"
 SG_ 归属 : 64 "全模型通用"
// ── H 工程交付能力 ──
BO_ H1 现场参数可调: CFG H
 SG_ 简述 : 64 "作业参数现场直接调整"
 SG_ 解释 : 512 "作业参数 (力度/速度/位置阈值/高度) 支持现场直接调整并立即生效, 调试不用改代码, 快速适配不同工件与工况。"
 SG_ 接口定义 : 512 "参数配置接口 (CFG)：输入调参指令, 输出生效参数与变更记录。"
 SG_ 输入 : 24 "调参指令 (参数名/新值/范围约束)"
 SG_ 输出 : 64 "生效参数 (确认回执/当前值) + 变更记录 (时间/新旧值)"
 SG_ 场景 : 128 "现场调试 · 参数整定 · 快速适配"
 SG_ 工程 : 128 "参数面板 + 数据字典"
 SG_ 归属 : 64 "全模型通用"
BO_ H2 方案文档交付: - H
 SG_ 简述 : 64 "一键生成方案与能力文档"
 SG_ 解释 : 512 "一键生成技术方案文档与能力清单, 交付口径统一, 客户评审有据可依。"
 SG_ 接口定义 : 512 "交付接口 (文档输出)：系统数据自动汇编为交付文档。"
 SG_ 输入 : 24 "系统数据 (方案画布/评估结果/指标统计, 自动汇总)"
 SG_ 输出 : 64 "交付文档 (方案/能力清单/报告)"
 SG_ 场景 : 128 "客户交付 · 技术选型 · 评审材料"
 SG_ 工程 : 128 "文档生成管道"
 SG_ 归属 : 64 "交付"
BO_ H3 远程查看: MON H
 SG_ 简述 : 64 "手机/网页随时查看运行情况"
 SG_ 解释 : 512 "支持手机/网页远程查看运行状态, 管理者随时随地巡检, 展会现场可演示。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：运行状态经远程通道展示。"
 SG_ 输入 : 24 "运行状态 (实时指标/作业画面/告警事件)"
 SG_ 输出 : 64 "远程展示页面 (网页/手机端, 实时刷新, 权限可配)"
 SG_ 场景 : 128 "管理者监控 · 远程巡检 · 展会展示"
 SG_ 工程 : 128 "远程展示页面"
 SG_ 归属 : 64 "全模型通用"

// 模型能力组合 (节点: 选用能力)
CM_ JOB_MODEL: A1 A2 A4 B1 B2 B3 B4 C1 C2 C3 C4 C5 C6 D1 D3 E1 E2 E3 F1 F2 G1 G2 G3 G4 H1 H3
CM_ GUIDE_MODEL: B1 B2 B4 D1 D2 G1
CM_ SCHED_MODEL: C1 D3 G2 G4 H1
CM_ PERCEPT_MODEL: B1 B2 B4 B5 G1
CM_ THIRD_PARTY: