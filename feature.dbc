VERSION "1.0"
// ═══════════════════════════════════════════════════
// feature.dbc — 能力数据库 (参考 Vector CANoe DBC)
// 同一平台/容器内配置不同模型的能力接入, 第三方模型按文件接入
// ═══════════════════════════════════════════════════

// 模型节点 (平台内可配置的模型/第三方接入点)
BU_: STATE_SPACE ACT SMOLVLA VLA_TOUCH YOLO

// 数据流形态 (状态空间=形态之一)
FLOW_: 感知 "感知" "现场信息 → 目标/状态认知 (识别/定位/触感)"
FLOW_: 决策 "决策" "认知 → 作业意图 (动作规划/预判/建模)"
FLOW_: 控制 "控制" "意图 → 动作指令 (分步编排/力度调节/平稳)"
FLOW_: 执行 "执行" "动作指令 → 机械作业 (7轴臂/夹爪/保护)"
FLOW_: STATE_SPACE "状态向量流 (决策=运动规律建模)" "状态空间模型" STATE_SPACE
FLOW_: ACT "图像+状态→动作流 (完整作业执行)" "ACT" ACT
FLOW_: SMOLVLA "视觉语言动作流 (统一决策)" "SmolVLA" SMOLVLA
FLOW_: VLA_TOUCH "视觉+触感→动作流 (力控作业)" "VLA-Touch" VLA_TOUCH
FLOW_: YOLO "感知专用流 (识别定位输出)" "YOLO 感知" YOLO

// 能力 (BO_) 与 输入输出信号 (SG_), 接口取值: IN/OUT/CFG/TRAIN/DEPLOY/EVAL/MON/SCHED
// ── A 感知能力 ──
BO_ A1 目标识别定位: IN A
 SG_ 简述 : 64 "识别工件/孔位/托盘等目标并给出位置"
 SG_ 解释 : 512 "目标识别定位是机器人的「眼睛」级能力：机器人通过现场相机获取作业画面，自动识别画面中的工件、孔位、托盘、料盒等目标对象，并给出每个目标的位置信息。该能力解决「机器人怎么知道东西在哪」的问题，是抓取、搬运、插拔等一切作业动作的前提。支持多目标同时识别，识别结果实时输出，供空间定位与作业决策使用。"
 SG_ 接口定义 : 512 "输入观测接口 (IN)：承载「现场信息 → 感知结果」的接入。输入为现场图像信号；输出为目标识别结果清单。该接口对感知类模型与决策类模型统一开放，第三方模型接入时按接口规范提供识别结果即可复用下游流程。"
 SG_ 输入 : 24 "现场图像 (相机采集, RGB 彩色, 640×480, 约30帧/秒)；相机标定参数 (内参/外参, 供坐标换算)"
 SG_ 输出 : 64 "目标清单 (每个目标: 类别名称, 置信度 0~1, 位置框 中心x/中心y/宽/高)；目标总数；单次识别耗时"
 SG_ 场景 : 128 "抓取前找工件 · 插拔前找孔位 · 上下料认托盘/料盒"
 SG_ 工程 : 128 "感知链模块 (yolo_3d/)"
 SG_ 归属 : 64 "感知（例YOLO）· 端到端动作（例ACT）"
BO_ A2 空间位姿感知: IN A
 SG_ 简述 : 64 "感知目标的三维位置与朝向"
 SG_ 解释 : 512 "空间位姿感知把「看到的目标」升级为「知道它在哪」：在目标识别的基础上，结合深度信息与相机标定，把 2D 画面中的目标换算成三维空间中的位置与朝向。该能力解决「机器臂怎么伸手去够」的问题，为抓取点计算、插拔对准、放置规划提供精确的空间参考。"
 SG_ 接口定义 : 512 "输入观测接口 (IN)：在目标识别结果之上扩展空间信息。输入为目标识别结果 + 现场深度/标定信息；输出为目标三维位姿。第三方感知模型提供识别结果后，可复用本接口完成空间换算。"
 SG_ 输入 : 24 "目标识别结果 (类别/位置框)；深度信息或标定参数 (用于坐标换算)"
 SG_ 输出 : 64 "目标三维位姿 (位置 x/y/z, 朝向 roll/pitch/yaw)；位姿置信度；换算耗时"
 SG_ 场景 : 128 "抓取点计算 · 插拔对准 · 放置规划"
 SG_ 工程 : 128 "感知链 2D→3D 适配"
 SG_ 归属 : 64 "端到端动作（例ACT）"
BO_ A3 触感感知: IN A
 SG_ 简述 : 64 "感知接触状态与力度大小"
 SG_ 解释 : 512 "触感感知让机器人「摸得到」：通过末端触觉传感，感知与物体的接触是否发生、接触力有多大、方向如何。该能力解决「机器人怎么知道碰到了、用多大力」的问题，是作业保护、抓取力度控制、插拔到位判断的基础，让精细操作不再「盲干」。"
 SG_ 接口定义 : 512 "输入观测接口 (IN)：承载触觉传感信息接入。输入为触觉原始信号；输出为接触状态与力度。支持与视觉/状态信号同步采样，供决策与保护联动。"
 SG_ 输入 : 24 "触觉原始信号 (传感器通道, 力/力矩分量)；采样时间戳"
 SG_ 输出 : 64 "接触状态 (是否接触/接触面)；力度 (力值大小与方向)；力度变化率 (供到位判断)"
 SG_ 场景 : 128 "插拔接触判断 · 抓取力度控制 · 防损伤"
 SG_ 工程 : 128 "触觉感知通道"
 SG_ 归属 : 64 "触觉力控（例VLA-Touch）· 状态空间（例状态空间模型）"
BO_ A4 自身状态感知: IN/CFG A
 SG_ 简述 : 64 "感知机械臂各关节与末端状态"
 SG_ 解释 : 512 "自身状态感知让机器人「知道自己是谁」：持续感知各关节角度、末端位置与姿态、运动速度等自身状态。该能力解决「机器人怎么知道自己的手在哪儿、姿态如何」的问题，是所有位置闭环、动作规划、状态上报的公共前提，任何模型接入都依赖这条能力。"
 SG_ 接口定义 : 512 "输入观测接口 (IN) + 参数配置接口 (CFG)：自身状态为全流程公共输入。输入为关节编码/运动状态；输出为关节与末端状态向量。状态维度可通过 CFG 配置（基础/完整/含触感等档位），适配不同模型需求。"
 SG_ 输入 : 24 "关节编码数据 (各关节角度)；运动学参数 (连杆长度/安装位姿)"
 SG_ 输出 : 64 "关节状态 (各关节角度/角速度)；末端状态 (位置/姿态/速度)；状态向量 (按配置维度组装)"
 SG_ 场景 : 128 "全模型共用 · 位置闭环 · 状态上报"
 SG_ 工程 : 128 "观测状态组装"
 SG_ 归属 : 64 "全模型通用"
// ── B 决策能力 ──
BO_ B1 完整作业执行: OUT B
 SG_ 简述 : 64 "学习并执行完整作业动作序列"
 SG_ 解释 : 512 "完整作业执行是机器人的「会干活」能力：通过训练数据学习一套完整的作业动作，从看到工件开始，自主完成抓取、搬运、插拔等连贯动作，中途不需要人工干预每一步。该能力解决「复杂作业怎么自动完成」的问题，作业越完整，产线越省人。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：承载「决策 → 动作」的下发。输入为现场观测；输出为完整动作序列。第三方决策模型按接口输出动作序列，即可驱动同一套执行与控制流程。"
 SG_ 输入 : 24 "现场观测 (图像/自身状态/触感, 按模型需求组合)"
 SG_ 输出 : 64 "动作序列 (每步: 各关节目标角/末端目标位姿/夹爪开合)；动作节奏 (每步时长)；执行状态回执"
 SG_ 场景 : 128 "插拔/搬运/对准等完整任务 · 数据充分的任务"
 SG_ 工程 : 128 "端到端动作策略"
 SG_ 归属 : 64 "端到端动作（例ACT）"
BO_ B2 过程预判: OUT B
 SG_ 简述 : 64 "预判后续过程走向, 提前调整"
 SG_ 解释 : 512 "过程预判让机器人「多想一步」：根据当前作业过程的观测，推断接下来会发生什么，提前调整动作。该能力解决「作业中途能不能提前纠偏」的问题，让长时序作业更连贯、少返工，异常出现前就有准备。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：在决策层提供预判结果输出。输入为当前过程观测；输出为预判结果（下一步走向/风险提示）。预判结果可旁路叠加到主决策，也可单独用于预警。"
 SG_ 输入 : 24 "当前过程观测 (图像/自身状态/动作历史, 按模型需求组合)"
 SG_ 输出 : 64 "预判结果 (下一步预期状态/动作)；偏差提示 (与预期不符的项)；预判置信度"
 SG_ 场景 : 128 "长时序作业 · 异常预警 · 动作预演"
 SG_ 工程 : 128 "预判旁路模块"
 SG_ 归属 : 64 "世界模型（例LEW）"
BO_ B3 运动规律建模: OUT B
 SG_ 简述 : 64 "建立运动规律模型, 支撑分析预测"
 SG_ 解释 : 512 "运动规律建模让机器人「懂自己怎么动」：基于自身运动数据建立运动规律模型，用于分析作业表现、预测运动结果、指导参数调整。该能力解决「机器人的动作能不能被科学分析」的问题，是稳定性分析、参数设计、表现预测的数学基础。状态空间只是该能力的一种数据流形态。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：输出运动规律模型供分析使用。输入为历史过程数据；输出为运动规律模型（可查询可预测）。模型对外提供「给定状态与控制 → 预期运动」的查询能力。"
 SG_ 输入 : 24 "历史过程数据 (状态序列/动作序列/时间戳)"
 SG_ 输出 : 64 "运动规律模型 (状态-控制-运动关系)；模型有效性指标 (拟合误差/适用范围)"
 SG_ 场景 : 128 "稳定性分析 · 控制参数设计 · 表现预测"
 SG_ 工程 : 128 "运动规律建模层"
 SG_ 归属 : 64 "状态空间（例状态空间模型）"
BO_ B4 精准到位: CFG/OUT B
 SG_ 简述 : 64 "快速平稳到达目标位置, 消除偏差"
 SG_ 解释 : 512 "精准到位让机器人「落点准」：把末端快速平稳地送到目标位置，并持续消除到位偏差。该能力解决「位置精度和到位速度怎么兼得」的问题，到达既快又不震荡、既准又不超调，是插拔对准、高精度定位的核心能力。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT) + 参数配置接口 (CFG)：到位过程由目标与参数共同驱动。输入为目标位置与当前状态；输出为到位控制指令。到位快慢/平稳程度通过 CFG 参数（力度档位/允许偏差）现场调节。"
 SG_ 输入 : 24 "目标位置 (三维位姿)；当前状态 (关节/末端)；允许偏差 (CFG 配置)"
 SG_ 输出 : 64 "到位控制指令 (逐周期输出)；到位状态 (到位/偏差量)；到位耗时 (供节拍统计)"
 SG_ 场景 : 128 "高精度定位 · 低偏差插拔 · 快速换位"
 SG_ 工程 : 128 "到位校正模块"
 SG_ 归属 : 64 "状态空间（例状态空间模型）· 轻量决策（例MLP）"
BO_ B5 决策说明: MON B
 SG_ 简述 : 64 "说明当前决策的依据, 过程可查"
 SG_ 解释 : 512 "决策说明让机器人「说得清为什么」：在作业的同时，输出当前决策的依据说明。该能力解决「机器人的决定能不能被信任和监督」的问题，让作业过程可解释、可回溯，异常时能快速归因，评审时拿得出依据。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：决策依据随运行数据一并上报。输入为当前观测与决策；输出为决策依据说明。说明内容可展示在大屏，也可归档供追溯查询。"
 SG_ 输入 : 24 "当前观测 (图像/状态/触感)；当前决策 (动作/阶段切换指令)"
 SG_ 输出 : 64 "决策依据说明 (要点列表)；决策置信度；关联观测引用 (支撑回溯)"
 SG_ 场景 : 128 "运行监督 · 异常归因 · 评审验收"
 SG_ 工程 : 128 "决策说明通道"
 SG_ 归属 : 64 "端到端动作（例ACT）"
// ── C 作业控制能力 ──
BO_ C1 分步作业编排: SCHED C
 SG_ 简述 : 64 "将作业分解为多阶段逐步完成"
 SG_ 解释 : 512 "分步作业编排让机器人「按步骤干活」：把复杂作业分解为多个阶段（如接近、抓取、抬起、转移、插入），每阶段独立管理，按完成条件逐段推进。该能力解决「复杂流程怎么可靠执行」的问题，阶段可单独调试、单独验收，异常时能回退到安全阶段。"
 SG_ 接口定义 : 512 "调度接入接口 (SCHED)：承载阶段编排与切换。输入为阶段完成条件评估；输出为阶段切换指令。阶段集合与各阶段参数通过配置定义，第三方模型按阶段接入即可。"
 SG_ 输入 : 24 "阶段完成条件 (各阶段到位/力值/时间等)；异常信号"
 SG_ 输出 : 64 "阶段切换指令 (进入下一阶段/回退)；阶段状态 (当前阶段/进度)"
 SG_ 场景 : 128 "插拔流程编排 · 多工序流转 · 异常回退"
 SG_ 工程 : 128 "作业阶段编排"
 SG_ 归属 : 64 "全模型通用"
BO_ C2 阶段力度调节: CFG C
 SG_ 简述 : 64 "不同作业阶段自动调节控制力度"
 SG_ 解释 : 512 "阶段力度调节让机器人「该柔则柔、该稳则稳」：根据当前作业阶段自动切换控制力度，接近时柔和渐进，插入时稳准有力。该能力解决「一个力度吃遍所有阶段」的不足，让每个阶段都有合适的作业手感，兼顾速度与安全。"
 SG_ 接口定义 : 512 "参数配置接口 (CFG)：力度参数按阶段配置并随阶段切换生效。输入为当前阶段；输出为控制力度参数组。各阶段力度档位现场可调，调完即生效。"
 SG_ 输入 : 24 "当前阶段编号；各阶段力度配置 (CFG 预设)"
 SG_ 输出 : 64 "控制力度参数 (当前阶段生效的力度/速度档位)"
 SG_ 场景 : 128 "分阶段作业 · 接近/抓取/插入差异化"
 SG_ 工程 : 128 "阶段参数调度"
 SG_ 归属 : 64 "状态空间（例状态空间模型）"
BO_ C3 作业保护: OUT/MON C
 SG_ 简述 : 64 "插拔/压合过程防损伤工件"
 SG_ 解释 : 512 "作业保护让机器人「下手有分寸」：在插拔、压合等接触类作业中实时感知力度，超过安全阈值立即调整或停止。该能力解决「作业会不会伤到工件」的问题，保护模块金手指、壳体等易损部位，是产线良率与安全的底线能力。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT) + 监控上报接口 (MON)：保护动作与保护记录双通道。输入为力度反馈；输出为保护性调整/停止指令，同时上报保护事件。安全阈值通过配置设定，现场可调。"
 SG_ 输入 : 24 "力度反馈 (触感/力值)；安全阈值 (CFG 配置)"
 SG_ 输出 : 64 "保护指令 (力度调整量/停止)；保护事件记录 (触发时间/力度值/阶段)"
 SG_ 场景 : 128 "模块插拔 · 金手指保护 · 压合保护"
 SG_ 工程 : 128 "力保护执行器"
 SG_ 归属 : 64 "全模型通用"
BO_ C4 平稳运行: OUT C
 SG_ 简述 : 64 "动作平滑无抖动冲击"
 SG_ 解释 : 512 "平稳运行让机器人「动作不毛躁」：对动作指令做平滑处理，避免抖动与冲击。该能力解决「高速作业与精密操作怎么兼得」的问题，既保持作业速度，又让末端动作顺滑，工件受力均匀、位置不漂移。"
 SG_ 接口定义 : 512 "动作输出接口 (OUT)：在动作下发链路中提供平滑处理。输入为原始动作指令；输出为平滑后动作指令。平滑强度（允许的加速度/速度上限）现场可调。"
 SG_ 输入 : 24 "原始动作指令；平滑参数 (速度/加速度上限, CFG 配置)"
 SG_ 输出 : 64 "平滑后动作指令；实际运动参数 (速度/加速度, 供监控)"
 SG_ 场景 : 128 "高速作业 · 精密操作 · 大惯量切换"
 SG_ 工程 : 128 "动作平滑模块"
 SG_ 归属 : 64 "全模型通用"
// ── D 数据能力 ──
BO_ D1 标准数据采集: TRAIN D
 SG_ 简述 : 64 "按行业标准格式采集与交换训练数据"
 SG_ 解释 : 512 "标准数据采集让机器人「学得有规矩」：按行业标准格式采集与组织训练数据（现场画面+状态+动作一一对应），数据可与外部工具、第三方模型互通。该能力解决「数据怎么攒、怎么换」的问题，是训练、评估、第三方接入的共同数据基础。"
 SG_ 接口定义 : 512 "训练接入接口 (TRAIN)：承载数据采集与训练对接。输入为现场采集流；输出为标准格式数据。标准格式对外公开，第三方训练工具可直接消费。"
 SG_ 输入 : 24 "现场采集流 (画面/状态/动作, 按采集任务)"
 SG_ 输出 : 64 "标准格式数据 (画面+状态+动作对齐)；数据质量信息 (样本数/覆盖情况)"
 SG_ 场景 : 128 "训练数据准备 · 数据交换 · 第三方模型复用"
 SG_ 工程 : 128 "标准数据集 (生态格式)"
 SG_ 归属 : 64 "全模型通用"
BO_ D2 边学边练: TRAIN D
 SG_ 简述 : 64 "现场作业中持续学习提升能力"
 SG_ 解释 : 512 "边学边练让机器人「越用越强」：现场作业中持续采集数据，定期更新能力，新数据不断反哺模型成长。该能力解决「产线数据怎么变成能力提升」的问题，新工位、新品种上线后，模型随作业数据积累持续变好。"
 SG_ 接口定义 : 512 "训练接入接口 (TRAIN)：承载采集→训练→部署闭环。输入为现场作业数据；输出为更新后的能力（新模型）。闭环流程自动化，训练完成自动部署验证。"
 SG_ 输入 : 24 "现场作业数据 (持续积累)；更新触发条件 (数据量/周期)"
 SG_ 输出 : 64 "更新后的能力 (新模型, 自动部署)；训练报告 (数据量/指标变化)"
 SG_ 场景 : 128 "产线持续优化 · 新工位快速适配"
 SG_ 工程 : 128 "采集→训练→部署闭环"
 SG_ 归属 : 64 "全模型通用"
BO_ D3 作业追溯: MON D
 SG_ 简述 : 64 "每件工件作业过程可查可审计"
 SG_ 解释 : 512 "作业追溯让机器人「干活留痕」：为每件工件记录作业过程与结果，按工件编号可查询完整档案。该能力解决「质量出了问题怎么查」的问题，满足产线质量审计要求，异常批次能快速定位到具体环节与参数。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：作业记录随运行数据归档。输入为工件编号与作业记录；输出为追溯档案。档案按工件编号索引，支持按时间/批次检索。"
 SG_ 输入 : 24 "工件编号；作业记录 (阶段/参数/结果/时间戳)"
 SG_ 输出 : 64 "追溯档案 (按工件查询)；批次统计 (良率/异常分布)"
 SG_ 场景 : 128 "产线验收 · 质量审计 · 异常批次定位"
 SG_ 工程 : 128 "作业记录归档"
 SG_ 归属 : 64 "产线部署版"
// ── E 学习训练能力 ──
BO_ E1 一键训练: TRAIN E
 SG_ 简述 : 64 "标准化配置即可完成训练"
 SG_ 解释 : 512 "一键训练让机器人「学得省事」：提供标准化训练流程，配置完成后一键完成训练，同一套流程可训练多种能力模型。该能力解决「训练门槛高、复现难」的问题，训练过程标准化、配置版本化，批量训练与对比评估轻松完成。"
 SG_ 接口定义 : 512 "训练接入接口 (TRAIN)：承载训练任务发起与结果回收。输入为训练数据与配置；输出为训练好的模型与报告。训练在标准环境中执行，配置存档可复现。"
 SG_ 输入 : 24 "训练数据 (标准格式)；训练配置 (模型档位/训练轮数/超参数)"
 SG_ 输出 : 64 "训练好的模型 (标准格式)；训练报告 (指标曲线/耗时/数据量)"
 SG_ 场景 : 128 "批量训练 · 多模型对比 · 配置复现"
 SG_ 工程 : 128 "容器化训练环境"
 SG_ 归属 : 64 "全模型通用"
BO_ E2 上岗前考核: EVAL E
 SG_ 简述 : 64 "正式作业前先经仿真考核验证能力"
 SG_ 解释 : 512 "上岗前考核让机器人「先考后上」：正式真机作业前，先在仿真环境完成能力考核，考核成功率与作业质量，达标后才允许真机作业。该能力解决「新模型能不能直接上岗」的风险问题，考核不过的模型不上线，现场风险大幅降低。"
 SG_ 接口定义 : 512 "评估接入接口 (EVAL)：承载考核任务与结果反馈。输入为待考核模型；输出为考核成绩与结论。考核环境与真机场景一致，成绩可作为上岗放行依据。"
 SG_ 输入 : 24 "待考核模型；考核场景配置 (作业任务/难度)"
 SG_ 输出 : 64 "考核成绩 (成功率/作业质量分)；考核结论 (达标/不达标)；考核录像"
 SG_ 场景 : 128 "模型选型 · 训练验收 · 版本对比"
 SG_ 工程 : 128 "仿真考核环境"
 SG_ 归属 : 64 "全模型通用"
BO_ E3 渐进式上岗: TRAIN E
 SG_ 简述 : 64 "从仿真到真机渐进迁移, 降低风险"
 SG_ 解释 : 512 "渐进式上岗让机器人「平稳过渡」：支持从仿真到真机的渐进式迁移，先在仿真环境打磨能力，再小范围试运行，最后逐步适配真机。该能力解决「仿真行、真机不行」的迁移落差问题，每一步都验证过再往前走，现场风险可控。"
 SG_ 接口定义 : 512 "训练接入接口 (TRAIN)：承载迁移各阶段的训练任务。输入为仿真训练模型与现场数据；输出为真机适配模型。迁移阶段按配置推进，每阶段有考核门槛。"
 SG_ 输入 : 24 "仿真训练模型 (标准格式)；现场试运行数据 (画面/状态/动作, 按阶段采集)"
 SG_ 输出 : 64 "真机适配模型；迁移报告 (各阶段成绩/数据量)"
 SG_ 场景 : 128 "仿真到真机迁移 · 新产线快速部署"
 SG_ 工程 : 128 "分阶段迁移流程"
 SG_ 归属 : 64 "端到端动作（例ACT）"
// ── F 部署运行能力 ──
BO_ F1 本地实时作业: DEPLOY F
 SG_ 简述 : 64 "机端本地实时完成作业, 不依赖外部网络"
 SG_ 解释 : 512 "本地实时作业让机器人「自己就能干」：感知、决策、作业全流程在机端本地实时完成，不依赖外部网络。该能力解决「产线断网/延迟会不会停摆」的问题，断网也能持续作业，满足 24 小时连续生产，反应快、延迟低。"
 SG_ 接口定义 : 512 "部署接入接口 (DEPLOY)：承载模型加载与运行。输入为现场观测；输出为实时作业动作。模型以标准格式部署到机端，加载后本地运行。"
 SG_ 输入 : 24 "现场观测 (实时)；已部署模型 (机端)"
 SG_ 输出 : 64 "实时作业动作；运行状态 (占用/温度/帧率, 供监控)"
 SG_ 场景 : 128 "产线实时作业 · 断网可用 · 低延迟"
 SG_ 工程 : 128 "机端运行环境 (Orin)"
 SG_ 归属 : 64 "全模型通用"
BO_ F2 远程升级: DEPLOY F
 SG_ 简述 : 64 "作业中可远程更新模型能力"
 SG_ 解释 : 512 "远程升级让机器人「升级不耽误干活」：新模型文件到位后自动加载生效，作业不停、升级不断。该能力解决「升级模型要不要停产」的问题，远程推送新能力，多台设备可批量更新，升级过程对产线透明。"
 SG_ 接口定义 : 512 "部署接入接口 (DEPLOY)：承载模型更新。输入为新模型文件；输出为更新生效状态。文件到位自动校验并切换，失败自动回退旧版本。"
 SG_ 输入 : 24 "新模型文件 (标准格式, 含完整性校验)；版本信息 (版本号/兼容性说明)"
 SG_ 输出 : 64 "更新生效状态 (成功/回退)；当前版本号"
 SG_ 场景 : 128 "远程升级 · 不停机换模型 · 批量部署"
 SG_ 工程 : 128 "模型文件监听生效"
 SG_ 归属 : 64 "全模型通用"
// ── G 对外协作能力 ──
BO_ G1 标准模型接入: IN/OUT G
 SG_ 简述 : 64 "按统一接口接入任意模型"
 SG_ 解释 : 512 "标准模型接入让机器人「谁都能来搭档」：提供统一的模型接入标准，任何第三方模型按标准接入即可，接入后共享训练、评估、部署、监控全流程。该能力解决「换模型要不要重新开发」的问题，接口统一、适配即用，模型生态自由扩展。"
 SG_ 接口定义 : 512 "标准接入契约 (IN/OUT 为主, 全接口统一)：输入为标准观测；输出为标准动作。第三方模型实现接入契约即可挂载，复用数据、训练、评估、部署、监控全链路。"
 SG_ 输入 : 24 "标准观测 (图像/状态/触感, 按契约组装)"
 SG_ 输出 : 64 "标准动作 (关节目标/夹爪, 按契约下发)"
 SG_ 场景 : 128 "第三方模型接入 · 模型替换 · 多模型对比"
 SG_ 工程 : 128 "统一接入契约 (8 接口)"
 SG_ 归属 : 64 "全模型通用"
BO_ G2 运行状态上报: MON G
 SG_ 简述 : 64 "作业状态与结果实时上报"
 SG_ 解释 : 512 "运行状态上报让机器人「随时被看见」：作业状态、成功率、节拍等运行数据实时上报，对接大屏与上位系统。该能力解决「产线情况怎么实时掌握」的问题，异常即时告警，指标可统计可验收，管理有据可依。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：承载运行数据对外上报。输入为运行数据；输出为上报表/告警。上报频率与指标集可配置，对接大屏/上位系统。"
 SG_ 输入 : 24 "运行数据 (状态/成功率/节拍/力值, 实时)"
 SG_ 输出 : 64 "上报记录 (指标时序)；告警事件 (超阈值/异常)"
 SG_ 场景 : 128 "产线监控 · 指标验收 · 异常告警"
 SG_ 工程 : 128 "指标上报通道"
 SG_ 归属 : 64 "全模型通用"
BO_ G3 事件自动通知: MON G
 SG_ 简述 : 64 "关键事件自动通知相关人员"
 SG_ 解释 : 512 "事件自动通知让机器人「有事会喊人」：训练完成、作业异常、报告输出等关键事件自动通知相关人员。该能力解决「人不盯着机器怎么办」的问题，重要节点即时送达，远程协作不误事，交付同步更顺畅。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：事件经通知通道外发。输入为系统事件；输出为通知消息。通知对象与事件类型可配置，支持携带附件（视频/报告）。"
 SG_ 输入 : 24 "系统事件 (训练完成/作业异常/报告就绪, 含事件详情与时间戳)"
 SG_ 输出 : 64 "通知消息 (事件摘要/附件链接/接收人)；送达回执"
 SG_ 场景 : 128 "远程协作 · 无人盯屏 · 交付同步"
 SG_ 工程 : 128 "消息通知通道"
 SG_ 归属 : 64 "全模型通用"
// ── H 工程交付能力 ──
BO_ H1 现场参数可调: CFG H
 SG_ 简述 : 64 "作业参数支持现场直接调整"
 SG_ 解释 : 512 "现场参数可调让机器人「好伺候」：作业参数（力度、速度、位置阈值等）支持现场直接调整并立即生效。该能力解决「现场微调要不要改代码」的问题，调试人员直接调参，快速适配不同工件与工况，上线速度更快。"
 SG_ 接口定义 : 512 "参数配置接口 (CFG)：承载参数查看与修改。输入为调参指令；输出为生效参数。参数变更记录归档，可回滚可追溯。"
 SG_ 输入 : 24 "调参指令 (参数名/新值)；参数范围约束"
 SG_ 输出 : 64 "生效参数 (确认回执/当前值)；参数变更记录 (变更时间/参数名/新旧值)"
 SG_ 场景 : 128 "现场调试 · 参数整定 · 快速适配"
 SG_ 工程 : 128 "参数面板 + 数据字典"
 SG_ 归属 : 64 "全模型通用"
BO_ H2 方案文档交付: - H
 SG_ 简述 : 64 "一键生成方案与能力文档"
 SG_ 解释 : 512 "方案文档交付让机器人「拿得出材料」：一键生成技术方案文档与能力清单，交付口径统一。该能力解决「交付材料怎么又快又一致」的问题，方案、特征、指标一页成文，客户评审有据可依，内部选型有据可查。"
 SG_ 接口定义 : 512 "交付接口 (文档输出)：系统数据自动汇编为交付文档。输入为系统数据（画布/评估/指标）；输出为方案文档与能力清单。文档模板统一，内容随系统数据实时更新。"
 SG_ 输入 : 24 "系统数据 (画布方案/评估结果/指标统计, 自动汇总)"
 SG_ 输出 : 64 "交付文档 (方案文档/能力清单/评估报告, 可导出分发)"
 SG_ 场景 : 128 "客户交付 · 技术选型 · 评审材料"
 SG_ 工程 : 128 "文档生成管道"
 SG_ 归属 : 64 "交付"
BO_ H3 远程查看: MON H
 SG_ 简述 : 64 "手机/网页随时查看运行情况"
 SG_ 解释 : 512 "远程查看让机器人「走哪都能看」：支持手机/网页远程查看运行状态，管理者随时随地巡检。该能力解决「人不在现场怎么看产线」的问题，展会现场可演示，出差途中可巡检，运行情况一目了然。"
 SG_ 接口定义 : 512 "监控上报接口 (MON)：运行状态经远程通道展示。输入为运行状态；输出为远程展示页面。多端适配（手机/电脑/大屏），访问权限可配置。"
 SG_ 输入 : 24 "运行状态 (实时指标/作业画面/告警事件)"
 SG_ 输出 : 64 "远程展示页面 (网页/手机端, 实时刷新, 权限可配)"
 SG_ 场景 : 128 "管理者监控 · 远程巡检 · 展会展示"
 SG_ 工程 : 128 "远程展示页面"
 SG_ 归属 : 64 "全模型通用"

// 模型能力组合 (节点: 选用能力)
CM_ STATE_SPACE: A1 A2 A3 A4 B3 B4 C1 C2 C3 C4 D1 D2 E1 E2 F1 F2 G1 G2 G3 H1 H3
CM_ ACT: A1 A2 A4 B1 C1 C3 C4 D1 D2 E1 E2 E3 F1 F2 G1 G2 G3 H1 H3
CM_ SMOLVLA: A1 A2 A4 B1 B2 C1 C3 C4 D1 D2 E1 E2 E3 F1 F2 G1 G2 G3 H1 H3
CM_ VLA_TOUCH: A1 A2 A3 A4 B1 B5 C1 C3 C4 D1 D2 E1 E2 E3 F1 F2 G1 G2 G3 H1 H3
CM_ YOLO: A1 A2 G1
